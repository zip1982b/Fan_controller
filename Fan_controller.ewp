# IAR project Fan_controller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ; inc\; CMSIS\inc\; FreeRTOS\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc\
  OBJCOPY.OOCOutputFile: Fan_controller.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DEBUG_CLASS_C (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG_CLASS_C
configuration Class_C (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CLASS_C
configuration Class_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CLASS_A
  group (top)
    ./: cayenne_lpp.c clock.c gpio.c main.c modemRHF78-052.c RingFIFO.c timer.c uart.c
  group CMSIS
    CMSIS/: startup_stm32f103xb.s
  group CMSIS/src
    CMSIS/src/: system_stm32f1xx.c
  group FreeRTOS/src
    FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c portasm.s queue.c stream_buffer.c tasks.c timers.c
  group inc
    inc/: cayenne_lpp.h clock.h FreeRTOSConfig.h gpio.h modemRHF78-052.h RingFIFO.h timer.h uart.h
